# Keil uVision project combination.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: combination +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: include.h main.c
  group keypad
    ./: keypad.c keypad.h
  group Initialize
    ./: initialize.c initialize.h
  group 12864lcd
    ./: 12864.c 12864.h
  group temp sensor
    ./: 18b20.c 18b20.h
  group serial
    ./: serial.c serial.h
  group led
    ./: pwm.c pwm.h
  group adc
    ./: adc.c adc.h
